Commit message: 修改；

File: cartographer_ros/urdf/coffee_pc.urdf (robot description, URDF)
Before this commit: robot coffee, 3 links, 2 joints
Joints:
- joint imu_link_joint: origin xyz=0 0 0 -> xyz=0 0 0.25
